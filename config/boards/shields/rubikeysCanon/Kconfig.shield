## config/boards/shields/rubikeysCanon/Kconfig.shield
```kconfig
config SHIELD_rubikeysCanon
    def_bool $(shields_list_contains, rubikeysCanon)
```
